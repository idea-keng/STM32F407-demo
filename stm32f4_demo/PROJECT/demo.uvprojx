# Keil uVision project demo.uvprojx, settings and files
target demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SYSTEM\delay;..\HARDWARE\SYSTEM\sys;..\HARDWARE\SYSTEM\usart;..\LIB\inc;..\LIB\src;..\START_UP;..\USER\inc;..\USER\src;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\ROCHER;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../USER/src/: main.c all_init.c lcd_display.c key_scanf.c
    ../USER/inc/: Chinese_font.h hardfile.h lcd_bmp.h
  group start_up
    ../START_UP/: startup_stm32f40_41xxx.s
  group cmsis
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group lib
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group hardware
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SYSTEM/delay/: delay.c
    ../HARDWARE/SYSTEM/sys/: sys.c
    ../HARDWARE/SYSTEM/usart/: usart.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ROCHER/: rocker.c
    ../HARDWARE/STMFLASH/: stmflash.c
